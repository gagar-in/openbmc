PACKAGECONFIG:append = " log-threshold log-watchdog send-to-logger log-alarm"